options:
  parameters:
    author: Dramco_Tianzheng
    generate_options: qt_gui
    id: Server
    output_language: python
    title: Server_process
  states: {}

blocks:
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import pmt
      from gnuradio import gr
      from collections import deque
      import time
      import os

      # ====== 关键：让 GRC 生成端口 ======
      in_sig = None
      out_sig = None
      in_msg = ['raw', 'dec']                 # 两路输入：raw / dec
      out_msg = ['stat', 'raw_out', 'dec_out']  # 三路输出：统计 + 两路转发
      # ===================================


      class blk(gr.sync_block):
          """
          Server-side PDU comparator (no GUI):
          - Input:  raw / dec PDUs (u8vector payload; usually bits 0/1)
          - Output: stat PDU (metadata only), raw_out PDU, dec_out PDU
          - Alignment:
              * Prefer seq in metadata: seq/frame_id/pkt_id/id
              * Otherwise FIFO alignment
          """

          def __init__(self,
                       print_every=50,
                       forward_every=10,
                       max_pending=200,
                       csv_path=""):
              gr.sync_block.__init__(
                  self,
                  name="Message Comparator (PDU bits) - server",
                  in_sig=None,
                  out_sig=None
              )

              # ---- params ----
              self.print_every = int(print_every)          # 每多少帧打印一次统计
              self.forward_every = int(forward_every)      # 每多少帧转发一次 raw/dec 到 PC
              self.max_pending = int(max_pending)          # 缓存上限防爆内存
              self.csv_path = str(csv_path).strip()

              # ---- ports ----
              # inputs
              self.message_port_register_in(pmt.intern("raw"))
              self.message_port_register_in(pmt.intern("dec"))
              self.set_msg_handler(pmt.intern("raw"), self._handle_raw)
              self.set_msg_handler(pmt.intern("dec"), self._handle_dec)

              # outputs
              self.message_port_register_out(pmt.intern("stat"))
              self.message_port_register_out(pmt.intern("raw_out"))
              self.message_port_register_out(pmt.intern("dec_out"))

              # ---- buffers ----
              # seq 对齐：缓存原始 msg + payload array
              self.raw_map = {}   # seq -> (msg, payload_u8)
              self.dec_map = {}   # seq -> (msg, payload_u8)

              # 无 seq：FIFO
              self.raw_fifo = deque()  # items: (msg, payload_u8)
              self.dec_fifo = deque()

              # ---- stats ----
              self.frames = 0
              self.total_bits = 0
              self.total_errs = 0
              self.len_mismatch = 0
              self.last_print_t = time.time()

              # ---- csv logging (optional) ----
              self._csv_fh = None
              if self.csv_path:
                  # 如果目录不存在尽量创建
                  d = os.path.dirname(self.csv_path)
                  if d and (not os.path.exists(d)):
                      os.makedirs(d, exist_ok=True)
                  self._csv_fh = open(self.csv_path, "a", buffering=1)
                  # 如果文件是空的，写表头
                  if self._csv_fh.tell() == 0:
                      self._csv_fh.write("timestamp,frames,bits,errs,ber,len_mismatch\n")

          # ---------------- utilities ----------------
          def _pdu_to_u8(self, msg):
              """Return (meta_dict, np.uint8 payload) or (None, None)."""
              if not pmt.is_pair(msg):
                  return None, None
              meta = pmt.car(msg)
              data = pmt.cdr(msg)

              try:
                  vec = pmt.u8vector_elements(data)
              except Exception:
                  return None, None

              meta_dict = {}
              if pmt.is_dict(meta):
                  try:
                      meta_dict = pmt.to_python(meta)
                  except Exception:
                      meta_dict = {}
              return meta_dict, np.frombuffer(bytes(vec), dtype=np.uint8)

          def _get_seq(self, meta_dict):
              """Try to extract sequence id from metadata."""
              for k in ("seq", "frame_id", "pkt_id", "id"):
                  if k in meta_dict:
                      try:
                          return int(meta_dict[k])
                      except Exception:
                          return None
              return None

          def _trim_pending(self):
              """Avoid unbounded growth."""
              while len(self.raw_map) > self.max_pending:
                  self.raw_map.pop(next(iter(self.raw_map)))
              while len(self.dec_map) > self.max_pending:
                  self.dec_map.pop(next(iter(self.dec_map)))

              while len(self.raw_fifo) > self.max_pending:
                  self.raw_fifo.popleft()
              while len(self.dec_fifo) > self.max_pending:
                  self.dec_fifo.popleft()

          def _publish_stat(self):
              """Publish a metadata-only PDU on 'stat'."""
              ber = (self.total_errs / self.total_bits) if self.total_bits > 0 else 0.0
              meta = pmt.make_dict()
              meta = pmt.dict_add(meta, pmt.intern("frames"), pmt.from_long(self.frames))
              meta = pmt.dict_add(meta, pmt.intern("bits"), pmt.from_long(self.total_bits))
              meta = pmt.dict_add(meta, pmt.intern("errs"), pmt.from_long(self.total_errs))
              meta = pmt.dict_add(meta, pmt.intern("ber"), pmt.from_double(float(ber)))
              meta = pmt.dict_add(meta, pmt.intern("len_mismatch"), pmt.from_long(self.len_mismatch))
              meta = pmt.dict_add(meta, pmt.intern("ts"), pmt.from_double(time.time()))

              pdu = pmt.cons(meta, pmt.init_u8vector(0, []))
              self.message_port_pub(pmt.intern("stat"), pdu)

              # optional CSV
              if self._csv_fh is not None:
                  self._csv_fh.write(f"{time.time()},{self.frames},{self.total_bits},{self.total_errs},{ber},{self.len_mismatch}\n")

              # also print to server console
              print(f"[Comparator] frames={self.frames}, bits={self.total_bits}, "
                    f"errs={self.total_errs}, BER={ber:.6e}, len_mismatch={self.len_mismatch}")

          def _compare_pair(self, raw_item, dec_item, seq=None):
              """
              raw_item/dec_item: (msg, payload_u8)
              Compare payloads; update stats; optionally forward raw/dec PDUs to PC.
              """
              raw_msg, raw_u8 = raw_item
              dec_msg, dec_u8 = dec_item

              n1, n2 = int(raw_u8.size), int(dec_u8.size)
              if n1 != n2:
                  self.len_mismatch += 1
                  n = min(n1, n2)
                  raw_u8 = raw_u8[:n]
                  dec_u8 = dec_u8[:n]
              else:
                  n = n1

              errs = int(np.count_nonzero(raw_u8 != dec_u8))
              self.frames += 1
              self.total_bits += n
              self.total_errs += errs

              # ---- forward raw/dec to PC (throttled) ----
              if self.forward_every > 0 and (self.frames % self.forward_every == 0):
                  # 原样转发收到的 PDU 最稳（保留 metadata/payload）
                  self.message_port_pub(pmt.intern("raw_out"), raw_msg)
                  self.message_port_pub(pmt.intern("dec_out"), dec_msg)

              # ---- publish stat periodically ----
              if self.print_every > 0 and (self.frames % self.print_every == 0):
                  self._publish_stat()

          # ---------------- handlers ----------------
          def _handle_raw(self, msg):
              meta, raw_u8 = self._pdu_to_u8(msg)
              if raw_u8 is None:
                  return

              seq = self._get_seq(meta)
              item = (msg, raw_u8)

              if seq is not None:
                  self.raw_map[seq] = item
                  if seq in self.dec_map:
                      dec_item = self.dec_map.pop(seq)
                      raw_item = self.raw_map.pop(seq)
                      self._compare_pair(raw_item, dec_item, seq=seq)
                  self._trim_pending()
              else:
                  self.raw_fifo.append(item)
                  if len(self.dec_fifo) > 0:
                      dec_item = self.dec_fifo.popleft()
                      raw_item = self.raw_fifo.popleft()
                      self._compare_pair(raw_item, dec_item, seq=None)
                  self._trim_pending()

          def _handle_dec(self, msg):
              meta, dec_u8 = self._pdu_to_u8(msg)
              if dec_u8 is None:
                  return

              seq = self._get_seq(meta)
              item = (msg, dec_u8)

              if seq is not None:
                  self.dec_map[seq] = item
                  if seq in self.raw_map:
                      raw_item = self.raw_map.pop(seq)
                      dec_item = self.dec_map.pop(seq)
                      self._compare_pair(raw_item, dec_item, seq=seq)
                  self._trim_pending()
              else:
                  self.dec_fifo.append(item)
                  if len(self.raw_fifo) > 0:
                      raw_item = self.raw_fifo.popleft()
                      dec_item = self.dec_fifo.popleft()
                      self._compare_pair(raw_item, dec_item, seq=None)
                  self._trim_pending()

          def stop(self):
              # 关闭 CSV
              try:
                  if self._csv_fh is not None:
                      self._csv_fh.close()
              except Exception:
                  pass
              return True
    csv_path: ''
    forward_every: '10'
    max_pending: '200'
    print_every: '50'
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://*:5555
    timeout: '100'
  states: {}
- name: zeromq_pull_msg_source_0_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://*:5556
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://*:7001
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://*:7003
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0_1
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://*:7002
    timeout: '100'
  states: {}

connections:
- [epy_block_0, dec_out, zeromq_push_msg_sink_0_0, in]
- [epy_block_0, raw_out, zeromq_push_msg_sink_0_1, in]
- [epy_block_0, stat, zeromq_push_msg_sink_0, in]
- [zeromq_pull_msg_source_0, out, epy_block_0, raw]
- [zeromq_pull_msg_source_0_0, out, epy_block_0, dec]

metadata:
  file_format: 1
  grc_version: 3.10.10.0
